# Keil uVision project F407_FC.uvprojx, settings and files
target Anopilot (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_FC +hex
  AfterMake: fromelf --bin !L --output TEST.ANO
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --c99
  c include: .\applications;.\build;.\drivers;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\USBStack\INC;.\Libraries\FatFS\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ./applications/: include.h stm32f4xx_conf.h main.c stm32f4xx_it.c scheduler.c init.c fly_ctrl.c parameter.c ctrl.c imu.c mymath.c data_transfer.c rc.c filter.c height_ctrl.c anotc_baro_ctrl.c PID.c fly_mode.c camera_datatransfer.c camera_data_calculate.c
  group Drivers
    ./applications/: version.c usb_config.c usbd_user_hid.c
    ./drivers/: time.c pwm_in.c pwm_out.c i2c_soft.c mpu6050.c ak8975.c led.c ms5611.c usart.c usbd_STM32F4xx_FS.c drv_w25qxx.c ultrasonic.c adc.c
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group USBStack
    ./Libraries/USBStack/SRC/: usbd_core.c usbd_core_hid.c usbd_hid.c
  group FatFs
    ./Libraries/FatFS/src/: diskio.c ff.c
  group Note
    ./doc/: note.txt record.txt 修改文档.txt 资料整理.txt
    ./: README.md
